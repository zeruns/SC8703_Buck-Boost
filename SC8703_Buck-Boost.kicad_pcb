# Repository zeruns/SC8703_Buck-Boost

File README.md:

# 【开源】基于SC8703的升降压DCDC可调电源（Buck-Boost），电压电流可调，支持PD快充输入

**开源一个基于SC8703芯片的Buck-Boost升降压DC/DC电源模块，输入电压最高36V，输入输出电流最高10A，开关频率600kHz，输出电压可调，输出电流恒流可调，最高转换效率95%，输入输出接口XT30，带TypeC口，支持PD快充输入，最高诱骗28V。**

---

## 设计参数

|      参数项       |      值      |
| :---------------: | :----------: |
|   输入电压范围    | 2.7V \~ 36V  |
|   输出电压范围    | 1.21V \~ 36V |
| 最大输入/输出电流 |     10A      |
| 输出恒流可调范围  | 0.58A \~ 10A |
|     开关频率      |    600kHz    |
|      PCB尺寸      | 79.6 x 47 mm |

Buck-Boost电源控制器芯片是SC8703，快充协议芯片是CH224Q。

---

## 复刻说明

1. **本项目使用KICAD设计的**，立创开源平台上的立创EDA项目为从KICAD工程文件导入的，所以会有点问题，复刻的建议直接用我提供的Gerber文件下单PCB。
2. 项目开源在 Gitee、立创开源硬件平台、华秋开源硬件社区，项目资料和开源平台链接在文章底部，提供的资料有 **KICAD项目文件、Gerber制板文件、详细BOM表（表里有元器件购买地址和价格）、顶层和底层拼一起的钢网文件、贴片丝印图、交互式BOM表（焊接辅助）、用到的芯片的数据手册文件、PCBA和外壳3D模型 等。**
3. 外壳是某宝购买的成品铝合金外壳，购买链接已放BOM表，外壳的前后面板是自己3D打印的，3D打印的3mf模型文件在资料里。
4. MOS管需通过散热硅胶垫与外壳接触导热！
5. 裸板不加散热时建议工作电流在5A以内！
6. Type-C口输入XT30输入接口是并联的，禁止同时使用！

小批量的元器件成本大概是30元/套（不含PCB、外壳），主要还是SC8703芯片贵，要9元左右每颗。

▶ **本项目视频演示：** [https://www.bilibili.com/video/BV1mMfPBzEXH/](https://www.bilibili.com/video/BV1mMfPBzEXH/)

▶ **电子/单片机技术交流QQ群： [2169025065](https://qm.qq.com/q/haWR2WfhIc)**

▶ **eeClub-电子工程师社区:** [https://bbs.eeclub.top/](https://bbs.eeclub.top/)

**求点个Star**

---

## 实物图片

---

## 焊接过程

用我提供的钢网文件去某宝打个10x10的钢网大概15元，然后自己3D打印一个刷锡膏的夹具，把钢网和PCB固定并对好位置，刷上锡膏，接着对照着交互式BOM表放好元器件，接着放上加热台或回流焊炉即可，建议先贴底层再贴顶层。

---

## 测试

通电测试，输入12V，输出24V，空载功耗0.37瓦左右。

TypeC输入测试，使用65W的PD充电头，诱骗出20V。

### 转换效率测试

睿登RD6012P数控可调电源简单开箱评测：[https://blog.zeruns.com/archives/740.html](https://blog.zeruns.com/archives/740.html)

**测得最高转换效率95.45%**

| 输入电压(V) | 输入电流(A) | 输入功率(W) | 输出电压(V) | 输出电流(A) | 输出功率(W) | 转换效率(%) |
| :---------: | :---------: | :---------: | :---------: | :---------: | :---------: | :---------: |
|   35.999    |    0.752    |   27.071    |   24.130    |    1.000    |   24.130    |   89.14%    |
|   35.999    |    6.699    |   241.157   |   23.954    |    9.600    |   229.955   |   95.35%    |
|    5.000    |    9.063    |   45.315    |   24.028    |    1.500    |   36.042    |   79.54%    |
|    5.000    |    8.520    |   42.600    |   12.054    |    3.000    |   36.162    |   84.89%    |
|   12.000    |    4.382    |   52.584    |    5.230    |    9.000    |   47.070    |   89.51%    |
|   11.999    |    8.753    |   105.027   |   24.048    |    4.000    |   96.192    |   91.59%    |
|    5.000    |    9.803    |   49.015    |   19.990    |    2.000    |   39.980    |   81.57%    |
|    5.000    |    5.063    |   25.315    |   21.116    |    1.000    |   21.116    |   83.41%    |
|   11.999    |    6.705    |   80.453    |   35.477    |    2.000    |   70.954    |   88.19%    |
|   35.999    |    3.459    |   124.521   |   11.998    |    9.510    |   114.097   |   91.63%    |
|   35.999    |    1.839    |   66.202    |   12.023    |    5.000    |   60.116    |   90.81%    |
|   35.999    |    9.288    |   334.359   |   35.460    |    9.000    |   319.141   |   95.45%    |

### MOS驱动波形

输入侧（Buck部分）MOS上管栅极对地波形，开关频率607kHz，周期1.65微秒左右，米勒平台持续时间20nS左右，正常，驱动波形比较干净，没有振铃，过冲很小。

输出侧（Boost部分）MOS上管栅极对地波形，开关频率607kHz，周期1.65微秒左右，MOS开启时存在过冲和振铃，应该是驱动走线不合理的问题。

### 纹波测试

普源(RIGOL) DHO914S示波器 简单开箱评测：[https://blog.zeruns.com/archives/764.html](https://blog.zeruns.com/archives/764.html)

输入12V，输出24V空载时，测得纹波峰峰值60mV左右。

输入12V，输出24V/2A时，测得纹波峰峰值200mV左右。

输入24V，输出5V空载时，测得纹波峰峰值16mV左右。

输入24V，输出5V/2A时，测得纹波峰峰值35mV左右。

### 发热情况热成像

不加任何散热，输入36V，输出24V/9.5A时MOS管温度5秒升到100℃以上。底面热成像图如下。

正面热成像图，SC8703芯片温度70度以上。

装上铝合金外壳后的热成像图，由于铝合金有点反光，避免影响测量结果所以在中间贴了个胶布，测得MOS管接触的那一面最高温度53℃左右。

---

## 资料下载地址

提供的资料有 **KICAD项目文件、Gerber制板文件、详细BOM表（表里有元器件购买地址和价格）、顶层和底层拼一起的钢网文件、贴片丝印图、交互式BOM表（焊接辅助）、用到的芯片的数据手册文件、PCBA和外壳3D模型 等。**

- Gitee开源地址：[https://gitee.com/zeruns/sc8703_-buck-boost](https://gitee.com/zeruns/sc8703_-buck-boost)
- Github开源地址：[https://github.com/zeruns/sc8703_-buck-boost](https://github.com/zeruns/sc8703_-buck-boost)
- 立创开源平台地址：[https://oshwhub.com/zeruns/sc8703_buck-boost](https://oshwhub.com/zeruns/sc8703_buck-boost)
- 华秋开源平台地址：[https://p.eda.cn/d-1341729185952956416](https://p.eda.cn/d-1341729185952956416)
- 123云盘下载地址：[https://www.123865.com/s/2Y9Djv-I9ddH](https://www.123865.com/s/2Y9Djv-I9ddH)

---

## 开源项目推荐

- **做了个三相电量采集器开源出来，可以方便监测家里用电情况：** [https://blog.zeruns.com/archives/771.html](https://blog.zeruns.com/archives/771.html)
- **基于STM32的同步整流Buck-Boost数字电源 开源：** [https://blog.zeruns.com/archives/791.html](https://blog.zeruns.com/archives/791.html)
- LM25118自动升降压可调DCDC电源模块：[https://blog.zeruns.com/archives/727.html](https://blog.zeruns.com/archives/727.html)
- **基于CH32V307的智能电子负载开源，嵌入式大赛作品开源：** [https://blog.zeruns.com/archives/785.html](https://blog.zeruns.com/archives/785.html)
- EG1151大功率同步整流可调升降压电源模块（支持TypeC PD快充输入）开源：[https://blog.zeruns.com/archives/794.html](https://blog.zeruns.com/archives/794.html)
- 开源 140W+65W升降压PD3.1快充模块(2C+1A口)，IP6557+IP6538，205W桌面充电器：[https://blog.zeruns.com/archives/801.html](https://blog.zeruns.com/archives/801.html)
- **开源TypeC拓展坞，4个10Gbps的USBA口+2.5G网卡+读卡器：**[https://blog.zeruns.com/archives/868.html](https://blog.zeruns.com/archives/868.html)
- 【开源】24V3A反激式开关电源（基于UC3842，含电路和变压器参数计算过程）：[https://blog.zeruns.com/archives/910.html](https://blog.zeruns.com/archives/910.html)

---

## 推荐阅读

- **高性价比和便宜的VPS/云服务器推荐:** [https://blog.zeruns.com/archives/383.html](https://blog.zeruns.com/archives/383.html)
- 我的世界开服教程：[https://blog.zeruns.com/tag/mc/](https://blog.zeruns.com/tag/mc/)
- GL-RM1PE 简单开箱测评和拆解，让普通电脑实现BMC远程管理功能：[https://blog.zeruns.com/archives/900.html](https://blog.zeruns.com/archives/900.html)
- Discourse论坛搭建教程，零基础部署Discourse开源社区论坛网站：[https://blog.zeruns.com/archives/919.html](https://blog.zeruns.com/archives/919.html)
- OWON HDS160 示波万用表 简单开箱测评和拆解：[https://blog.zeruns.com/archives/927.html](https://blog.zeruns.com/archives/927.html)
- 我的世界一键快速开服教程，支持各个MC版本（forge、fabric、paper、基岩 等等）：[https://blog.zeruns.com/archives/923.html](https://blog.zeruns.com/archives/923.html)

## KiCad design SC8703_Buck-Boost.kicad_pcb

Parts:
C1, C2: NC; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C3, C4: 47pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C5, C10, C24, C25: 220uF; CP_Elec_10x10.5
C6, C7, C8, C11, C12, C13: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C9, C14, C16, C18: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C15, C17, C20, C23: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C19, C21: 10nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C22: 15nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1: LED-RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3: TPB2A100-123FL; D_SOD-123F
D4: SB1045L; MPN SB1045L
J1: XT30PW-M; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: XT30PW-F; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
L1: 4.7uH; L_APV_APH1265
Q1, Q2, Q3, Q4: XRS100N06LD; DFN-8_L3.0-W3.0-P0.65-BL-4
R1, R2: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R3, R4, R5, R6: 510R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R8: 5mR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R9, R10, R13, R14: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R17, R18: 12.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R15: 68k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16: NC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; not fitted
R19: 15k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R20: 1.74k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 210k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
RV1: 200k; Potentiometer_Bourns_3296X_Horizontal
RV2: 50k; Potentiometer_Bourns_3296X_Horizontal
U1: SC8703; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm
U2: CH224Q; DFN-10_L2.0-W2.0-P0.40-BL-EP

Connections:
/BT1: C16.1, D2.1 (K), U1.29 (BT1)
/BT2: C18.1, D3.1 (K), U1.20 (BT2)
/CC1: J3.A5 (CC1), U2.7 (CC1)
/CC2: J3.B5 (CC2), U2.6 (CC2)
/D+: J3.A6 (D+), J3.B6 (D+), U2.4 (DP)
/D-: J3.A7 (D-), J3.B7 (D-), U2.5 (DM)
/FB: R20.2, RV2.1, RV2.2, U1.16 (FB)
/FREQ: R16.2, U1.10 (FREQ)
/HD1: R9.1, U1.28 (HD1)
/HD2: R10.2, U1.21 (HD2)
/ILIM1: C19.2, R17.2, U1.11 (ILIM1)
/ILIM2: C21.2, R18.2, U1.12 (ILIM2)
/LD1: R13.1, U1.26 (LD1)
/LD2: R14.2, U1.23 (LD2)
/SNS1_N: C3.2, R4.2, U1.31 (SNS1N)
/SNS1_P: C3.1, R3.2, U1.32 (SNS1P)
/SNS2_N: C4.2, R6.2, U1.17 (SNS2N)
/SNS2_P: C4.1, R5.2, U1.18 (SNS2P)
/SW1: C16.2, L1.1, Q1.3 (S), Q3.1 (D), R1.2, U1.27 (SW1)
/SW2: C18.2, L1.2, Q2.3 (S), Q4.1 (D), R2.2, U1.22 (SW2)
/VBUS: C23.2, D4.1 (A), D4.3 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U2.1 (VHV), U2.8 (VBUS)
GND: C1.1, C2.1, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C17.2, C19.1, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, D1.1 (K), J1.1, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), Q3.3 (S), Q4.3 (S), R15.1, R16.1, R17.1, R20.1, R21.2, RV1.1, U1.1 (CE#), U1.2 (AGND), U1.9 (AGND), U1.14 (AGND), U1.25 (PGND), U1.33 (PGND), U2.11 (EP)
unnamed: C1.2, R1.1
unnamed: C2.2, R2.1
unnamed: C22.2, R19.1
unnamed: D1.2 (A), R11.1, R12.1
unnamed: Q1.1 (D), R4.1, R7.2
unnamed: Q1.2 (G), R9.2
unnamed: Q2.1 (D), R5.1, R8.1
unnamed: Q2.2 (G), R10.1
unnamed: Q3.2 (G), R13.2
unnamed: Q4.2 (G), R14.1
unnamed: R18.1, RV1.2, RV1.3
unnamed: R19.2, U1.15 (COMP)
unnamed: R15.2, U1.8 (DT)
unnamed: R21.1, U2.9 (CFG1)
VCC: C17.1, D2.2 (A), D3.2 (A), U1.24 (VCC)
VIN: C5.1, C6.1, C7.1, C8.1, C9.2, C15.1, C24.1, D4.2 (K), J1.2, R3.1, R7.1, U1.7 (UVLO), U1.30 (VIN)
VOUT: C10.1, C11.1, C12.1, C13.1, C14.2, C20.1, C25.1, J2.2, R6.1, R8.2, R11.2, R12.2, RV2.3, U1.19 (VOUT)

Notes on the sheet:
RC吸收电路
快充诱骗输出28V
输入限流：10.2A 输出限流：0.58-10.2A 可调
输出电压：2.5V-36.2V 可调

Board: 2 copper layers, 79.6 x 47.0 mm, 62 parts (26 on the bottom side), 39 nets.

File 02-生产文件/BOM.xlsx:

Designator | Footprint | Quantity | Value | 规格 | 单价 | 总价 | 购买链接
C1, C2, R1, R2 | 0603 | 4 | NC |  |  | 0
C10, C24, C25, C5 | CP_Elec_10x10.5 | 4 | 220uF | 贴片固态电容, 220uF,±20%,50V, SMD 10*10.5mm | 1.32 | 5.28 | https://s.click.taobao.com/t?e=m%3D2%26s%3DFc2%2BoSDpx6pw4vF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
C11, C12, C13, C6, C7, C8 | 1206 | 6 | 10uF | 1206贴片电容, 10uF,±10%,50V,X5R | 0.22 | 1.32 | https://s.click.taobao.com/t?e=m%3D2%26s%3DHR%2Bo%2FAiMNEhw4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
C14, C16, C18, C9 | 0402 | 4 | 100nF | 0402贴片电容, 100nF,±10%,50V,X7R | 0.033 | 0.132 | https://s.click.taobao.com/t?e=m%3D2%26s%3DsKl9WbKqhDBw4vFB6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
C15, C17, C20, C23 | 0402 | 4 | 1uF | 0402贴片电容, 1uF,±10%,50V,X5R | 0.0859 | 0.3436 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
C19, C21 | 0402 | 2 | 10nF | 0402贴片电容, 10nF,±10%,50V,X7R | 0.033 | 0.066 | https://s.click.taobao.com/t?e=m%3D2%26s%3DsKl9WbKqhDBw4vFB6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
C22 | 0402 | 1 | 15nF | 0402贴片电容, 15nF,±10%,50V,X7R | 0.0073 | 0.0073 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
C3, C4 | 0402 | 2 | 47pF | 0402贴片电容, 47pF,±5%,50V,C0G | 0.033 | 0.066 | https://s.click.taobao.com/t?e=m%3D2%26s%3DsKl9WbKqhDBw4vFB6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
D1 | 0603 | 1 | LED-RED | 0603贴片LED, 红色 | 0.0275 | 0.0275 | https://s.click.taobao.com/t?e=m%3D2%26s%3DyaAa0gmyoIxw4vFB6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
D2, D3 | D_SOD-123F | 2 | TPB2A100-123FL | 肖特基二极管, TPB2A100-123FL, SOD-123FL | 0.32607 | 0.65214 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
D4 | SB1045L | 1 | SB1045L | 肖特基二极管, SB1045L, TO-277 | 0.81 | 0.81 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
J1 | AMASS_XT30PW-M_1x02_P2.50mm_Horizontal | 1 | XT30PW-M | XT30航模插头, 卧式弯脚公头, XT30PW-M | 1.8 | 1.8 | https://s.click.taobao.com/t?e=m%3D2%26s%3DL8r5aSlkSwlw4vFB6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
J2 | AMASS_XT30PW-F_1x02_P2.50mm_Horizontal | 1 | XT30PW-F | XT30航模插头, 卧式弯脚母头, XT30PW-F | 1.5 | 1.5 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
J3 | USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A | 1 | USB_C_Receptacle_USB2.0_16P | Type-C 16P母座(四脚插外壳7.3长), 卧贴 | 0.17 | 0.17 | https://s.click.taobao.com/t?e=m%3D2%26s%3D1jNVXOYEf%2F5w4vF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
L1 | L_APV_APH1265 | 1 | 4.7uH | 1265一体成型电感, 4.7uH, 额定电流10A以上, 饱和电流12A以上 | 1.76 | 1.76 | https://s.click.taobao.com/t?e=m%3D2%26s%3DABa9CzglPcRw4vFB6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
Q1, Q2, Q3, Q4 | DFN-8_L3.0-W3.0-P0.65-BL-4 | 4 | XRS100N06LD | N-MOS, XRS100N06LD, PDFN-8L(3.3x3.3) | 1.04247 | 4.16988 | https://activity.szlcsc.com/invite/D03E5B9CEAAE70A4.html
R10, R13, R14, R9 | 0603 | 4 | 0R | 0603贴片电阻, 0Ω,±1% | 0.0176 | 0.0704 | https://s.click.taobao.com/t?e=m%3D2%26s%3DSqphNGSpjLVw4vFB6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
R11, R12, R17, R18 | 0402 | 4 | 12.1k | 0402贴片电阻, 12.1kΩ,±1% | 0.0132 | 0.0528 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R15 | 0402 | 1 | 68k | 0402贴片电阻, 68kΩ,±1% | 0.0132 | 0.0132 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R16 | 0402 | 1 | NC |  |  | 0
R19 | 0402 | 1 | 15k | 0402贴片电阻, 15kΩ,±1% | 0.0132 | 0.0132 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R20 | 0402 | 1 | 1.74k | 0402贴片电阻, 1.74kΩ,±1% | 0.0132 | 0.0132 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R21 | 0402 | 1 | 210k | 0402贴片电阻, 210kΩ,±1% | 0.0132 | 0.0132 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R3, R4, R5, R6 | 0402 | 4 | 510R | 0402贴片电阻, 510Ω,±1% | 0.0132 | 0.0528 | https://s.click.taobao.com/t?e=m%3D2%26s%3D%2BQAFD3zUqR1w4vF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
R7, R8 | 1206 | 2 | 5mR | 1206贴片合金采样电阻, 5mΩ,±1% | 0.242 | 0.484 | https://s.click.taobao.com/t?e=m%3D2%26s%3Do7mNRwhHvQ5w4vFB6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
RV1 | Potentiometer_Bourns_3296X_Horizontal | 1 | 200k | 可调多圈电位器, 侧调, 3296X, 200kΩ | 0.49 | 0.49 | https://s.click.taobao.com/t?e=m%3D2%26s%3DCIwL%2F%2BMzhu5w4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
RV2 | Potentiometer_Bourns_3296X_Horizontal | 1 | 50k | 可调多圈电位器, 侧调, 3296X, 50kΩ | 0.49 | 0.49 | https://s.click.taobao.com/t?e=m%3D2%26s%3DCIwL%2F%2BMzhu5w4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
U1 | QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm | 1 | SC8703 | DCDC控制器芯片, SC8703QDER, QFN-32, SOUTHCHIP(南芯) | 9.06 | 9.06 | https://s.click.taobao.com/t?e=m%3D2%26s%3Dan%2BB5uFwMq5w4vF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
U2 | DFN-10_L2.0-W2.0-P0.40-BL-EP | 1 | CH224Q | 快充协议芯片, CH224Q, DFN-10-EP(2x2), WCH(南京沁恒) | 1.15 | 1.15 | https://s.click.taobao.com/t?e=m%3D2%26s%3DyD%2FA1DdmCjNw4vF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
 |  |  |  |  | 元器件总价 | 30.00722
 |  |  |  |  | 总价 | 37.00722
 |  |  |  | 铝合金外壳, 50x20x80 |  | 7 | https://s.click.taobao.com/t?e=m%3D2%26s%3Dm7ppRc7pyjxw4vFB6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
 |  |  |  | 导热硅胶垫 |  |  | https://s.click.taobao.com/t?e=m%3D2%26s%3Dq38cTSvCi45w4vFB6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
 |  |  |  | PCB
 |  |  |  | SMT

## Commit log

2026-02-01 创建项目
2026-02-01 补充中文版数据手册，原理图放置SC8703芯片
2026-02-02 原理图完成5%
2026-02-03 原理图完成80%，上传数据手册
2026-02-03 完成原理图设计
2026-02-03 PCB layout 完成5%
2026-02-03 修正输出电容数值
2026-02-04 XT30封装加入3D模型
2026-02-04 PCB完成95%
2026-02-05 设计完成，下单打样
2026-02-11 SB1045L绑定3D模型，导出PCBA 3D模型
2026-02-11 导出PCBA 3D模型
2026-02-14 导出原理图和丝印图PDF
2026-02-15 优化项目目录结构，上传外壳资料，导出丝印图
2026-02-15 上传符号库表文件和封装库表文件
2026-02-18 更新生产文件
2026-02-20 更新文档
2026-02-24 导出PCBA的GLB格式3D模型
